Properties of the parts of a building model (IFC2X3)

# File
Description: Raumhygrostat, Aufputz, 24 VAC bis 230 VAC, 35…85 % r.H., Wechsler, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA020203, Raumhygrostat, Aufputz, 24 VAC bis 230 VAC, 35…85 % r.H., Wechsler, Inneneinstellung
In: Raum
Description: Der Raumhygrostat dient zur Überwachung und Regelung der relativen Feuchte, z. B. in Geschäftsräumen, Wohnungen, Wintergärten, Bädern, Schwimmbädern, EDV-Räumen und anderen Räumen mit sauberer, nichtaggressiver Umgebung entwickelt. Durch die Einwirkung der relativen Feuchte auf ein Messband wird ein potentialfreier Umschaltkontakt betätigt. Wegen der Inneneinstellung des Sollwerts besonders für Behörden, Schulen und ähnlich öffentliche Gebäude geeignet.; Classification: EC011175 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA020203; ModelLabel: RFHSB-060.011; GlobalTradeItemNumber: 4050528073150; ProductURL: https://alre.de/produkt_MA020203
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.063
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 78.3; Höhe: 83.4; Tiefe: 25.5; RAL-Nummer: 9010; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Haarelement; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 5; Messbereich unterer Wert (relative Luftfeuchtigkeit): 35; Messbereich oberer Wert (relative Luftfeuchtigkeit): 85; Schaltdifferenz einstellbar: no; Ablesbar: no; ETIM-Klasse: EC011175; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA020203.pdf
